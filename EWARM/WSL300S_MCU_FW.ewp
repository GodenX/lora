# IAR project WSL300S_MCU_FW.ewp, settings and files
configuration WSL300S_MCU_FW (ARM, debug)
  General.OGChipSelectEditMenu: STM32L051K8 ST STM32L051K8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L051xx; REGION_CN470
  ICCARM.IExtraOptions: "--enable_restrict"
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include; ../Middlewares/Third_Party/Lora/Core; ../Middlewares/Third_Party/Lora/Crypto; ../Middlewares/Third_Party/Lora/Mac; ../Middlewares/Third_Party/Lora/Utilities; ../Middlewares/Third_Party/Lora/Phy; ../sx1276
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WSL300S_MCU_FW.srec
  ILINK.IlinkOutputFile: WSL300S_MCU_FW.out
  ILINK.IlinkIcfFile: stm32l051xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l051xx.s
  group Application/User
    ../Src/: adc.c app_scheduler.c at.c command.c debug.c dma.c gpio.c hw_gpio.c hw_rtc.c hw_spi.c i2c.c i2cemu.c lora.c main.c rtc.c spi.c stm32l0xx_hal_msp.c stm32l0xx_hw.c stm32l0xx_it.c test_rf.c tiny_sscanf.c tiny_vsnprintf.c usart.c vcom.c WSL300S.c
  group Components
    ../sx1276/: sx1276.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group Middlewares/Core
    ../Middlewares/Third_Party/Lora/Core/: lora-test.c
  group Middlewares/Crypto
    ../Middlewares/Third_Party/Lora/Crypto/: aes.c cmac.c
  group Middlewares/Mac
    ../Middlewares/Third_Party/Lora/Mac/: LoRaMac.c LoRaMacCrypto.c
    ../Middlewares/Third_Party/Lora/Mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionUS915-Hybrid.c RegionUS915.c
  group Middlewares/Utilities
    ../Middlewares/Third_Party/Lora/Utilities/: delay.c low_power_manager.c timeServer.c utilities.c
